require pyronear-image.inc
SUMMARY = "Pyronear Production Image"
