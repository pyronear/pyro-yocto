# Use the Compose v5 package
COMPOSE_PKG = "github.com/docker/compose/v5"